options:
  parameters:
    generate_options: no_gui
    id: weird_am
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: filter_power
  id: variable
  parameters:
    value: sum(t*t for t in lp_taps)
  states: {}
- name: interp
  id: variable
  parameters:
    value: '125'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '37500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '-263675'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '0.5'
    high_cutoff_freq: '2900'
    low_cutoff_freq: '100'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(lp_taps) - 1) // 2
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: noise.sigmf-data
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(filter_power) * 1.09
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * offset / samp_rate
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: flag.wav
    repeat: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lp_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    type: fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_delay_0, '0']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_delay_0, '0', blocks_sub_xx_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_sub_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_arg_0, '0']
- [fir_filter_xxx_0, '0', blocks_sub_xx_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
