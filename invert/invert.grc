options:
  parameters:
    generate_options: qt_gui
    id: invert
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: invert_freq
  id: variable
  parameters:
    value: '3339'
  states: {}
- name: invert_hi
  id: variable
  parameters:
    value: '2800'
  states: {}
- name: invert_lo
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: '100'
  states: {}
- name: wav_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: wav_rate
    fh: invert_freq
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '530e-6'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: wav_rate
    fh: invert_hi
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '530e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: invert_freq
    offset: '0'
    phase: '0'
    samp_rate: wav_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: invert_lo
    offset: '0'
    phase: '0'
    samp_rate: wav_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: invert_lo + invert_hi
    offset: '0'
    phase: '0'
    samp_rate: wav_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.cf32
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: out2.cf32
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: test.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: test.wav
    repeat: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_freq
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_freq
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_lo
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_hi
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_lo
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: invert_hi
    decim: '1'
    gain: '1'
    samp_rate: wav_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_file_sink_0, '0']
- [analog_nbfm_tx_0_0, '0', blocks_file_sink_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0_0, '0', low_pass_filter_0_1, '0']
- [blocks_wavfile_source_0_0, '0', low_pass_filter_0_1_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0_1, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_0_1_0, '0', blocks_multiply_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
