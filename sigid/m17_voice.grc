options:
  parameters:
    generate_options: no_gui
    id: m17_voice
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: delay
  id: variable
  parameters:
    value: (n_taps - 1) // 2
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: audio_rate // 4800
  states: {}
- name: m17_deviation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: n_symbols
  id: variable
  parameters:
    value: os.path.getsize("voice_symbols.s8")
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: interpolation_rate*11+1
  states: {}
- name: offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: m17_deviation * 2 * math.pi / audio_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sigid6.sigmf-data
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: voice_symbols_padded.s8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0] * (192 * interpolation_rate + delay) + [1] * (n_symbols * interpolation_rate) + [0] * (192 * interpolation_rate - delay)'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_file_source_1, '0', blocks_char_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_rotator_cc_0, '0']
- [root_raised_cosine_filter_0_0, '0', analog_frequency_modulator_fc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
