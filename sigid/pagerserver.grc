options:
  parameters:
    author: cstone@pobox.com
    category: Custom
    description: Example flowgraph for PDU-driven pager server
    generate_options: no_gui
    id: pagerserver
    output_language: python
    run_options: run
  states: {}

blocks:
- name: max_deviation
  id: variable
  parameters:
    value: '4800.0'
  states: {}
- name: pagerfreq
  id: variable
  parameters:
    value: '931337500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: symrate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2.0 * math.pi * max_deviation / float(symrate)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: out.syms
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * offset / samp_rate
  states: {}
- name: filename
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mixalot_flexencode_0
  id: mixalot_flexencode
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: offset
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: float(samp_rate)/float(symrate)
    type: ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: pagerfreq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '37'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_rotator_cc_0, '0', blocks_add_xx_0, '0']
- [mixalot_flexencode_0, '0', blocks_char_to_float_0, '0']
- [mixalot_flexencode_0, '0', blocks_file_sink_1, '0']
- [mixalot_flexencode_0, beeps_output, network_socket_pdu_0, pdus]
- [mixalot_flexencode_0, cmds_out, uhd_usrp_sink_0, command]
- [network_socket_pdu_0, pdus, mixalot_flexencode_0, beeps]
- [pfb_arb_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']
- [pfb_arb_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
